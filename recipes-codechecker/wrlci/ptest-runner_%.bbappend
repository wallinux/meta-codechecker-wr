
inherit codechecker

CODECHECKER_ANALYZE_ARGS = "--verbose=info --ctu -e sensitive"
CODECHECKER_PARSE_ARGS = "--verbose=info"
CODECHECKER_STORE_ARGS = "--verbose=info"
