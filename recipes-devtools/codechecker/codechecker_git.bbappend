FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-added-RCS-gcc-options-to-IGNORED_OPTIONS_GCC.patch"
